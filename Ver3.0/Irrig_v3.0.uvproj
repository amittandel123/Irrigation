# Keil uVision project Irrig_v3.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Irrig_v3.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c keypad.c lcd.c lcd.h keypad.h
